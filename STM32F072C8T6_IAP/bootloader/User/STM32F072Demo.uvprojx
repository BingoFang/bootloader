# Keil uVision project STM32F072Demo.uvprojx, settings and files
target Stm32f072_bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F072Demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c misc: --c99
  c include: ..\CORE;..\HARDWARE;..\User;..\SYSTEM;..\STM32F0xx_FWLib\inc;..\STM32F0xx_FWLib\src
  memory RVCT4: ROM 0x8000000 size 0x2800
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c
  group CORE
    ../CORE/: startup_stm32f0xx.s
  group HARDWARE
    ../HARDWARE/: led.c can.c bootloader.c can_queue.c protocol_parse.c
  group SYSTEM
    ../SYSTEM/: delay.c
  group STM32F0xx_FWLib
    ../STM32F0xx_FWLib/src/: stm32f0xx_can.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_flash.c
